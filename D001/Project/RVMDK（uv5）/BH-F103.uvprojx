# Keil uVision project BH-F103.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\Led;..\..\User\SysTick;..\..\User\time;..\..\User\mqtt;..\..\User\wifi;..\..\User\md;..\..\User\schedule;..\..\User\pwm;..\..\User\OLED;..\..\User\OLED2;..\..\User\USART1;..\..\User\USART4;..\..\User\USART5;..\..\User\nrf;..\..\User\USART2;..\..\User\JQ8X00;..\..\User\USART3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group Code
    ../../User/: main.c stm32f10x_it.c
    ../../User/schedule/: schedule.c
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/Led/: bsp_led.c
    ../../User/time/: timer2.c timer3.c timer4.c
    ../../User/USART5/: usart5.c
    ../../User/USART1/: usart.c
  group Utils
    ../../User/md/: utils_hmac.c utils_md5.c utils_sha1.c
  group Wifi_esp8266
    ../../User/mqtt/: mqtt.c
    ../../User/wifi/: wifi.c
    ../../User/USART2/: usart2.c
  group PWM
    ../../User/pwm/: IIC1.c pca9685.c
  group OLED
    ../../User/OLED2/: bsp_i2c_2.c OLED_I2C_2.c
    ../../User/OLED/: bsp_i2c.c OLED_I2C.c
  group nrf24l01
    ../../User/nrf/: bsp_spi_nrf.c
  group JQ8400
    ../../User/JQ8X00/: JQ8X00.c
    ../../User/USART4/: usart4.c
  group Offline_Connect
    ../../User/USART3/: usart3.c
